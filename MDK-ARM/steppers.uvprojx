# Keil uVision project steppers.uvprojx, settings and files
target steppers (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F072RB STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.5.0
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: steppers
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F072xB
  c misc: --C99
  c include: ../Inc;    ../Drivers/STM32F0xx_HAL_Driver/Inc;    ../Drivers/STM32F0xx_HAL_Driver/Inc/Legacy;    ../Drivers/CMSIS/Device/ST/STM32F0xx/Include;    ../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --diag_suppress=L6329
  group Application/User
    ../Src/: main.c stm32f0xx_it.c stm32f0xx_hal_msp.c gpio.c queue.c stepper.c stepper_control.c uart.c
    ../Src/include/: gpio.h queue.h stepper.h stepper_control.h uart.h
  group Drivers/CMSIS
    ../Src/: system_stm32f0xx.c
  group Application/MDK-ARM
    ./: startup_stm32f072xb.s
  group Drivers/STM32F0xx_HAL_Driver
    ../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal_tim_ex.c stm32f0xx_hal_dma.c stm32f0xx_hal_i2c_ex.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_flash.c stm32f0xx_hal.c stm32f0xx_hal_tim.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_rcc.c stm32f0xx_hal_gpio.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_i2c.c stm32f0xx_hal_pwr.c stm32f0xx_hal_cortex.c stm32f0xx_hal_uart.c stm32f0xx_hal_uart_ex.c
software components: CMSIS:CORE 4.1.0
